## Config.in
```kconfig
config BR2_PACKAGE_PATHFINDER
	bool "Pathfinder"
	help
		Include pathfinder in build
```
